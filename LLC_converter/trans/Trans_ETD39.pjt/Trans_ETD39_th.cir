*****************************************************
*    PExprt THERMAL MODEL FOR MAGNETIC COMPONENT    *
*            PSPICE (R) LANGUAGE VERSION            *
* GENERATED BY PExprt (TM). © 2022 UPM-SAS IP, Inc. *
*                  Release 2022 R2                  *
*****************************************************

.subckt Trans_ETD39_th  AvgCoreLosses  AvgWireLosses  TempMax

VdcCore AvgCoreLosses Core_int 0

RCoreLosses Core_int 0 1.0e+000

VdcConductor AvgWireLosses Conductor_int 0

RConductorLosses Conductor_int 0 1.0e+000

*.. 2D Thermal model description for PSPICE

*..Power sources for different losses

*.. CoreLosses

GPcore 0 Pcore VALUE={i(VdcCore)}

Rcore  Pcore 0 1.0e+000

*..Power sources for different windings

*.Winding 1

GPwind1 0 Pwind1 VALUE={i(VdcConductor)*3177.32/(

+3177.32

++373.959

++453.903

++533.847)}

Rwind1  Pwind1 0 1.0e+000

*.Winding 2

GPwind2 0 Pwind2 VALUE={i(VdcConductor)*373.959/(

+3177.32

++373.959

++453.903

++533.847)}

Rwind2  Pwind2 0 1.0e+000

*.Winding 3

GPwind3 0 Pwind3 VALUE={i(VdcConductor)*453.903/(

+3177.32

++373.959

++453.903

++533.847)}

Rwind3  Pwind3 0 1.0e+000

*.Winding 4

GPwind4 0 Pwind4 VALUE={i(VdcConductor)*533.847/(

+3177.32

++373.959

++453.903

++533.847)}

Rwind4  Pwind4 0 1.0e+000

*..Temperature node for magnetic component

GTempMax 0 TempMaxprev VALUE={

+v(Pcore)*10.9109

++v(Pwind1)*10.0735

++v(Pwind2)*10.0749

++v(Pwind3)*10.0735

++v(Pwind4)*10.0724}

RTempMax TempMaxprev 0 1.0e+006

ETempOut TempMax 0 VALUE={v(TempMaxprev)/(TIME+1.0e-012)}

CavgTempMax TempMaxprev 0  1 IC=0.0

*..End of the Thermal Model of The Magnetic Component

.ends
